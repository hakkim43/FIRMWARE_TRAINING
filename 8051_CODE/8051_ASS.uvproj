# Keil uVision project 8051_ASS.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80C51BH Intel
  cpu: IRAM(0-0x7F)  IROM(0-0xFFF) CLOCK(12000000)
  output: 8051_ASS
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: PROG1.asm prog2.asm prog3.asm prog4.asm prog5.asm
